include u-boot-imx6-dhcom.inc

PV = "v2015.10"

# use latest source
SRCREV = "${AUTOREV}"
