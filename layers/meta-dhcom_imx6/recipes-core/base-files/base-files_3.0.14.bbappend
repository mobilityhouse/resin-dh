do_install_prepend () {
    echo "alias ll='ls -alF'" >> ${WORKDIR}/profile
}
