UBOOT_KCONFIG_SUPPORT = "1"
inherit resin-u-boot

#FILESEXTRAPATHS_append_imx6-dhcom := ":${THISDIR}/patches"
#SRC_URI_append_imx6-dhcom = "file://imx6-dhcom-integrate-with-resin-configuration.patch"
